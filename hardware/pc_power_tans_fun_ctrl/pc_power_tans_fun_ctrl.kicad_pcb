# Repository songzhishuo/PC_POWER_TRANS_FUN_CTRL

File README.md:

# PC_POWER_TRANS_FUN_CTRL
电脑风扇控制

# 功能说明

通过此模块完成对电脑电源的控制，可以实现温度控制。

PS 不是PID控温，只是简单的范围控温。

# 接线说明

一般情况下风扇为12V电源，因此需要从电源线上引出12V接风扇的控制脚。

5V也需要从电源引出给单片机进行供电。右侧J1连接DS18B20即可。

## KiCad design hardware/pc_power_tans_fun_ctrl/pc_power_tans_fun_ctrl.kicad_pcb

Parts:
C1, C2: 104; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1, J2: Conn_01x03; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
Q1: IRF540N; TO-263-2
R1: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: STC8G1K08A; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C2.1, J1.3, J2.1, R1.2, R2.1, U1.2 (VCC/AVCC/VREF+)
FAN_PIN: Q1.1 (G), R2.2, U1.5 (P3.3/ADC11/INT1/MISO_4/I2C_SDA_4)
GND: C1.2, C2.2, J1.1, J2.3, Q1.3 (S), U1.4 (GND)
unnamed: J2.2, Q1.2 (D)
UART_RxD: U1.8 (P3.0/ADC8/RxD/INT4)
UART_TxD: U1.7 (P3.1/ADC9/TxD)
WIRE_PIN: J1.2, R1.1, U1.6 (P3.2/ADC10/INT0/SCLK_4/I2C_SCL_4)

Notes on the sheet:
接DS18B20 1:GND 2:DQ 3:VDD

Board: 2 copper layers, 27.9 x 12.7 mm, 8 parts (1 on the bottom side), 5 nets.

## Commit log

2022-12-11 Add: add ignore file in this project
2022-12-11 Add: add C51 keil project
2022-12-12 Add: add hardware sheet and README.md
