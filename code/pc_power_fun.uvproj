# Keil uVision project pc_power_fun.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: pc_power_fun +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c system.c PCA_PWM.c ds18b20.c soft_pwm.c
